<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\AD9959_circle.ewp</path>
  </project>
  <batchBuild />
</workspace>
